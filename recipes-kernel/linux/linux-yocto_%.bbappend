FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://snappy.cfg"
